# Keil uVision project uart_console.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: uart_console +hex
  AfterMake: fromelf.exe --bin -o uart_console.bin ./output/uart_console.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,iprintf=platform_printf,TRACE_BUFF_SIZE=1024
  c misc: --gnu
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src;../../SDK_Project/src/StartUP/ing918;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x1e000
  memory RVCT9: RAM 0x200057e0 size 0x2820
  group APP
    ./src/: main.c profile.c uart_console.c AOA_service.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9185xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_pinctrl.c
  group Tools
    ../../src/Tools/: trace.c str_util.c gatt_client_util.c
software components: CMSIS:CORE 5.5.0
